options:
  parameters:
    generate_options: qt_gui
    id: audio_record
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=PCH,DEV=0
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: chakana_audio
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
