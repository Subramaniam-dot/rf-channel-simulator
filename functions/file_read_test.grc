options:
  parameters:
    generate_options: qt_gui
    id: file_read_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/subramaniam/PhD/rf-channel-simulator/analogue/AM/output_29.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
