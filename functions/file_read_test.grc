options:
  parameters:
    generate_options: qt_gui
    id: file_read_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/henry/GRC/rf-channel-simulator/analogue/AM/mod_AM_snr_40.0/output_1.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/henry/GRC/rf-channel-simulator/analogue/AM/mod_AM_snr_40.0/output_27.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/henry/GRC/rf-channel-simulator/analogue/AM/mod_AM_snr_40.0/output_70.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/henry/GRC/rf-channel-simulator/analogue/AM/mod_AM_snr_40.0/output_78.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_file_source_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0_0_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_file_source_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_file_source_0_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [blocks_file_source_0_0_0_0, '0', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
