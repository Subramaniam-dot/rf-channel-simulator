options:
  parameters:
    description: FM modulation adapted from the GNC Tutorial page
    generate_options: qt_gui
    id: FM
    output_language: python
    title: FM Audio modulation
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '20'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: freq_off_max
  id: variable
  parameters:
    value: +samp_rate/2
  states: {}
- name: freq_off_min
  id: variable
  parameters:
    value: '-samp_rate/2'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.2'
    step: '0.001'
    stop: '0.2'
    value: '0'
    widget: eng_slider
  states: {state: disabled}
- name: freq_offset
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {state: disabled}
- name: noise_volt
  id: variable
  parameters:
    value: "(lambda x: signal_voltage / __import__('math').pow(10, x / 20))(SNR)\n\n\n\n\n\n"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: signal_voltage
  id: variable
  parameters:
    value: '1'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0001'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate*1
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.15'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=PCH,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_offset
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/eez096/Desktop/rf-channel-simulator/Audio_Recording/767102__audiomirage__strange-language.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: ../../Audio_Recording/audio
    repeat: 'True'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass custom_file_writer(gr.sync_block):\n    def __init__(self, filename='output.dat', num_samples=1024):\n        gr.sync_block.__init__(self, name=\"custom_file_writer\", in_sig=[np.complex64], out_sig=None)\n        self.counter = 0\n        self.samples_per_file = num_samples\n        self.filename = filename\n\n        # Create message port for enabling writing\n        self.message_port_register_in(gr.pmt.intern(\"enable_write\"))\n        self.set_msg_handler(gr.pmt.intern(\"enable_write\"), self.handle_message)\n\n        # Buffer to hold incoming data\n        self.buffer = []\n\n    def handle_message(self, msg):\n        # Check if the message is a boolean 'true' (1)\n        if gr.pmt.is_true(msg):\n            self.write_to_file()\n\n    def write_to_file(self):\n        # Check if there are enough samples in the buffer\n        if len(self.buffer) < self.samples_per_file:\n            return  # Not enough data to write\n\n        # Write the specified number of samples to a file\n        filename = f\"{self.filename}_{self.counter}.dat\"\n        with open(filename, 'ab') as f:\n            # Write the first `num_samples` samples to the file\n            f.write(np.array(self.buffer[:self.samples_per_file]).tobytes())\n        \n        # Remove written samples from buffer\n        self.buffer = self.buffer[self.samples_per_file:]  \n        \n        self.counter += 1\n\n    def work(self, input_items, output_items):\n        # Append incoming samples to the buffer\n        self.buffer.extend(input_items[0])  # Add new samples to the buffer\n        return len(input_items[0])  # Return the number of samples processed\n\n"
    filename: '"output"'
    num_samples: '1024'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import logging
      class blk(gr.sync_block):
          """Random Number Generator"""
          def __init__(self, min_val=0, max_val=1):
              gr.sync_block.__init__(
                  self,
                  name='Random Number Generator',
                  in_sig=None,
                  out_sig=None)
              
              self.min_val = float(min_val)
              self.max_val = float(max_val)
              
              # Message ports
              self.message_port_register_in(pmt.intern('trigger'))
              self.message_port_register_out(pmt.intern('rand_out'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_trigger)
              
              # Setup logging
              logging.basicConfig(level=logging.INFO)
              self.logger = logging.getLogger("random_num_gen")
          
          def set_min_val(self, min_val):
              """Callback to update minimum value"""
              self.min_val = float(min_val)
              
          def set_max_val(self, max_val):
              """Callback to update maximum value"""
              self.max_val = float(max_val)
              
          def handle_trigger(self, msg):
              # Generate new random number
              rand_num = np.random.uniform(self.min_val, self.max_val)
              
              # Create message
              #msg = pmt.from_double(rand_num)
              msg = pmt.cons(pmt.PMT_NIL, pmt.from_double(rand_num))
              # Send the message
              self.message_port_pub(pmt.intern('rand_out'), msg)
              
              # Log
              self.logger.info(f"Sending random number: {rand_num}")

          def work(self, input_items, output_items):
              return 0
    max_val: freq_off_max
    min_val: freq_off_min
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for Custom File Writer
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from collections import deque
      import logging
      import os

      class blk(gr.sync_block):
          def __init__(self, filename='output', num_samples=2048,
                   modulation_scheme="AM", snr=10000.0, freq_offset=1000.0, max_files=500):
              gr.sync_block.__init__(
                  self,
                  name='Custom File Writer',
                  in_sig=[np.complex64],
                  out_sig=None)

              # Register message ports
              self.message_port_register_in(pmt.intern("enable_write"))
              self.set_msg_handler(pmt.intern("enable_write"), self.handle_message)
              # Add output message port for write signal
              self.message_port_register_out(pmt.intern("write"))
          
              # Parameters
              self._last_snr = None
              self._last_freq_offset = None
              self.snr = float(snr)
              self.freq_offset = float(freq_offset)
              self.counter = 0
              self.samples_per_file = int(num_samples)
              self.base_filename = str(filename)
              self.modulation_scheme = str(modulation_scheme)
              self.max_files = int(max_files)
              self.buffer = deque()
              self.done = False
              self.enable_write = False
              
              # Setup logging
              logging.basicConfig(level=logging.INFO)
              self.logger = logging.getLogger("custom_file_writer")
              
              # Setup initial directory
              self.setup_directory()
              
              self.logger.info(f"Initialized with SNR={self.snr}, freq_offset={self.freq_offset}")

          def set_snr(self, snr):
              """SNR parameter callback"""
              self.snr = float(snr)
              self.logger.info(f"SNR changed to: {self.snr}")
              self.check_parameters()

          def set_freq_offset(self, freq_offset):
              """Frequency offset parameter callback"""
              self.freq_offset = float(freq_offset)
              self.logger.info(f"Frequency offset changed to: {self.freq_offset}")
              self.check_parameters()

          def check_parameters(self):
              """Check if parameters have changed"""
              if (self._last_snr != self.snr) or (self._last_freq_offset != self.freq_offset):
                  self.logger.info(f"New parameter combination detected - SNR: {self.snr}, Freq Offset: {self.freq_offset}")
                  self._last_snr = self.snr
                  self._last_freq_offset = self.freq_offset
                  self.counter = 0
                  self.done = False
                  self.setup_directory()
                  return True
              return False

          def setup_directory(self):
              """Create directory for current parameters"""
              # Remove freq_offset from directory name since it changes for each file
              self.dir_name = f"mod_{self.modulation_scheme}_snr_{self.snr}"
              if not os.path.exists(self.dir_name):
                  os.makedirs(self.dir_name)
              self.filename = os.path.join(self.dir_name, self.base_filename)
              self.logger.info(f"Created directory: {self.dir_name}")
      	    
          def write_metadata_file(self, filename):
              """Write metadata file with current parameters"""
              meta_filename = filename.replace(".dat", ".txt")
              try:
                  with open(meta_filename, 'w') as meta_file:
                      meta_file.write(f"Modulation Scheme = {self.modulation_scheme}\n")
                      meta_file.write(f"Signal to Noise Ratio = {self.snr} dB\n")
                      meta_file.write(f"Frequency Offset = {self.freq_offset} Hz\n")
                      meta_file.write(f"Number of Samples = {self.samples_per_file}\n")
                      meta_file.write(f"File Number = {self.counter + 1} of {self.max_files}\n")
              except IOError as e:
                  self.logger.error(f"Failed to write metadata file: {e}")
       
          def handle_message(self, msg):
              """Handle enable_write messages"""
              try:
                  if pmt.is_pair(msg):
                      value = pmt.to_python(pmt.cdr(msg))
                  elif pmt.is_bool(msg):
                      value = pmt.to_python(msg)
                  else:
                      value = bool(pmt.to_python(msg))
                  
                  self.enable_write = value
                  
                  if self.enable_write:
                      # Always check parameters when writing is enabled
                      self.check_parameters()
                      if not self.done:
                          self.write_to_file()
                      else:
                          self.logger.info(f"Already completed {self.max_files} files for current parameters")
              except Exception as e:
                  self.logger.error(f"Error in message handler: {e}")

          def write_to_file(self):
              """Write samples to file"""
              if self.done or not self.enable_write:
                  return
                  
              if len(self.buffer) < self.samples_per_file:
                  self.logger.warning(f"Buffer contains only {len(self.buffer)} samples, need {self.samples_per_file}")
                  return
                  
              
              
              filename = f"{self.filename}_{self.counter}.dat"
              try:
                  with open(filename, 'wb') as f:
                      samples_to_write = list(self.buffer)[:self.samples_per_file]
                      f.write(np.array(samples_to_write, dtype=np.complex64).tobytes())
                  
                  self.write_metadata_file(filename)
                  
                  
                  self.buffer.clear()
                  
                  # Send write trigger message before writing file
                  self.message_port_pub(pmt.intern("write"), pmt.to_pmt("trigger"))
                  
                  #for _ in range(self.samples_per_file):
                  #    self.buffer.popleft()
                      
                  self.counter += 1
                  self.logger.info(f"Writing to {self.dir_name}: File {self.counter} of {self.max_files}")
                  
                  if self.counter >= self.max_files:
                      self.done = True
                      self.enable_write = False
                      self.logger.info(f"Completed generating {self.max_files} files for {self.dir_name}")
              except IOError as e:
                  self.logger.error(f"Failed to write data file: {e}")

          def work(self, input_items, output_items):
              """Process incoming samples"""
              if self.done:
                  return len(input_items[0])
                  
              self.buffer.extend(input_items[0])
              
              if len(self.buffer) >= self.samples_per_file and self.enable_write and not self.done:
                  self.write_to_file()
                  
              return len(input_items[0])
    filename: '"output"'
    freq_offset: freq_offset
    max_files: '100'
    modulation_scheme: '"FM"'
    num_samples: '2048'
    snr: SNR
  states: {}
- name: id_write_button
  id: variable_qtgui_msg_push_button
  parameters:
    label: write
    msgName: pressed
    type: bool
    value: '1'
  states: {state: disabled}
- name: id_write_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: real
    value: freq_offset
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Audio Signal
    label2: FM Modulated Waveform
    name: '"Raw and Modulated Data"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_complex_to_float_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [audio_source_0, '0', blocks_selector_0, '2']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_selector_0, '1']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [epy_block_0_0, rand_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_1, write, epy_block_0_0, trigger]
- [id_write_button, pressed, epy_block_0, enable_write]
- [id_write_button_0, pressed, epy_block_1, enable_write]
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [low_pass_filter_0, '0', channels_channel_model_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', epy_block_1, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
