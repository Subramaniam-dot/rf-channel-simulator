options:
  parameters:
    description: FM modulation adapted from the GNC Tutorial page
    generate_options: qt_gui
    id: AM
    output_language: python
    title: AM Audio modulation
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: (1**2/noise_volt**2)
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.2'
    step: '0.001'
    stop: '0.2'
    value: '0.00'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.2'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0001'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=Generic_1,DEV=0
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../Audio_Recording/audio
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: ../../Audio_Recording/audio
    repeat: 'True'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: custom_file_writer_1
  id: custom_file_writer
  parameters:
    filename: output
    freq_offset: freq_offset
    modulation_scheme: AM
    num_samples: '2048'
    snr: SNR
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass custom_file_writer(gr.sync_block):\n    def __init__(self, filename='output.dat', num_samples=1024):\n        gr.sync_block.__init__(self, name=\"custom_file_writer\", in_sig=[np.complex64], out_sig=None)\n        self.counter = 0\n        self.samples_per_file = num_samples\n        self.filename = filename\n\n        # Create message port for enabling writing\n        self.message_port_register_in(gr.pmt.intern(\"enable_write\"))\n        self.set_msg_handler(gr.pmt.intern(\"enable_write\"), self.handle_message)\n\n        # Buffer to hold incoming data\n        self.buffer = []\n\n    def handle_message(self, msg):\n        # Check if the message is a boolean 'true' (1)\n        if gr.pmt.is_true(msg):\n            self.write_to_file()\n\n    def write_to_file(self):\n        # Check if there are enough samples in the buffer\n        if len(self.buffer) < self.samples_per_file:\n            return  # Not enough data to write\n\n        # Write the specified number of samples to a file\n        filename = f\"{self.filename}_{self.counter}.dat\"\n        with open(filename, 'ab') as f:\n            # Write the first `num_samples` samples to the file\n            f.write(np.array(self.buffer[:self.samples_per_file]).tobytes())\n        \n        # Remove written samples from buffer\n        self.buffer = self.buffer[self.samples_per_file:]  \n        \n        self.counter += 1\n\n    def work(self, input_items, output_items):\n        # Append incoming samples to the buffer\n        self.buffer.extend(input_items[0])  # Add new samples to the buffer\n        return len(input_items[0])  # Return the number of samples processed\n\n"
    filename: '"output"'
    num_samples: '1024'
  states: {state: disabled}
- name: id_write_button
  id: variable_qtgui_msg_push_button
  parameters:
    label: write
    msgName: pressed
    type: bool
    value: '1'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Audio Signal
    label2: AM Modulated Data
    name: Raw and Modulated Data
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [audio_source_0, '0', blocks_selector_0, '2']
- [band_pass_filter_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_selector_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_selector_0, '1']
- [channels_channel_model_0_0, '0', custom_file_writer_1, '0']
- [channels_channel_model_0_0, '0', epy_block_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [id_write_button, pressed, custom_file_writer_1, enable_write]
- [id_write_button, pressed, epy_block_0, enable_write]
- [low_pass_filter_0_0, '0', channels_channel_model_0_0, '0']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
