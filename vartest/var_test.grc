options:
  parameters:
    generate_options: qt_gui
    id: var_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import random

      class blk(gr.sync_block):
          def __init__(self, samp_rate=32000):  # Add samp_rate parameter
              gr.sync_block.__init__(
                  self,
                  name='Random Frequency Generator',
                  in_sig=None,
                  out_sig=None)
              self.samp_rate = samp_rate  # Store samp_rate
              self.message_port_register_in(pmt.intern('trigger'))
              self.message_port_register_out(pmt.intern('freq'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_trigger)
              
          def handle_trigger(self, msg):
              # Generate random frequency between -samp_rate/2 and +samp_rate/2
              new_freq = random.uniform(-self.samp_rate/2, self.samp_rate/2)
              # Create PMT message
              msg = pmt.cons(pmt.intern("freq"), pmt.from_double(new_freq))
              # Send the message
              self.message_port_pub(pmt.intern('freq'), msg)

          def work(self, input_items, output_items):
              return len(output_items[0])
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: real
    value: freq+1000
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, freq, blocks_msgpair_to_var_0, inpair]
- [variable_qtgui_msg_push_button_0, pressed, epy_block_0, trigger]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
